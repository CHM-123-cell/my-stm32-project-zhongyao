# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\user;.\hardware;.\library;.\start
  asm define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  asm include: .\user;.\hardware;.\library;.\start
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\test.sct
  group User
    ./user/: main.c stm32f10x_it.c
  group Hardware
    ./hardware/: timer.c oled.c Serial.c Serial.h servo.c servo.h sensor.c sensor.h
  group Library
    ./library/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_usart.c
  group Startup
    ./start/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
